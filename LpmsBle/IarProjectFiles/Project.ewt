<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32373C-EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Libraries</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_sdadc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F37x_StdPeriph_Driver\src\stm32f37x_wwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\system_stm32f37x.c</name>
    </file>
  </group>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\..\Source\CommunicationManager.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\i2c_mpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\inv_mpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\inv_mpu_dmp_motion_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\openmat-closedsource\LpFilterCVersion.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpMagnetometerCalibration.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpMatrix.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsAssignments.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsBmp180.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsModbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsMpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsRs232Usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsSensorParameters.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsStartUp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsTest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\LpmsTimebase.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorManager.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\startup_stm32f37x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\stm32f37x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Watchdog.c</name>
    </file>
  </group>
</project>


