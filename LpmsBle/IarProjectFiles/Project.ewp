# IAR project Project.ewp, settings and files
configuration STM32373C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373xC ST STM32F373xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; ARM_MATH_CM4; USE_STDPERIPH_DRIVER; USE_CANBUS_INTERFACE; USE_LPMSCU_NEW; USE_TTL_UART_INTERFACE
  ICCARM.CCIncludePath2: ..\Source; ..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
    ../Source/: system_stm32f37x.c
  group Source
    ../Source/: CommunicationManager.c i2c_mpu.c inv_mpu.c inv_mpu_dmp_motion_driver.c LpMagnetometerCalibration.c LpMatrix.c LpmsAssignments.c LpmsBmp180.c LpmsConfig.c LpmsModbus.c LpmsMpu.c LpmsRs232Usart.c LpmsSensorParameters.c LpmsStartUp.c LpmsTest.c LpmsTimebase.c main.c SensorManager.c startup_stm32f37x.s stm32f37x_it.c Watchdog.c
    ../../openmat-closedsource/: LpFilterCVersion.c
