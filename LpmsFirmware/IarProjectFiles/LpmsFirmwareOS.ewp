# IAR project LpmsFirmwareOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205rx ST STM32F205rx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_BLUETOOTH_INTERFACE; USE_HEAVEMOTION
  ICCARM.CCIncludePath2: ..\STM32F2xx_Libraries\CMSIS\CM3; ..\STM32F2xx_Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\LpmsSource; ..\STM32F2xx_Libraries\Common; ..\CanFestival
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LpmsB.bin
  ILINK.IlinkOutputFile: LpmsB.out
  ILINK.IlinkIcfFile: LpmsFirmware.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../STM32F2xx_Libraries/CMSIS/CM3/: core_cm3.c
  group LpmsSource
    ../LpmsSource/: CommunicationManager.c HeaveMotionOS.c LpFilterCVersionOS.c LpMagnetometerCalibration.c LpMatrix.c LpmsAssignments.c LpmsBmp180.c LpmsCanBus.c LpmsConfig.c LpmsL3gd20.c LpmsLsm303dlhc.c LpmsModbus.c LpmsRn42.c LpmsSensorParameters.c LpmsStartUp.c LpmsTest.c LpmsTimebase.c LpmsUsart.c main.c SensorManager.c
  group STM32F2xx_Common
    ../STM32F2xx_Libraries/Common/: startup_stm32f2xx.s stm32f2xx_it.c system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../STM32F2xx_Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
